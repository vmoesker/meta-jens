FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-bohr-${PV}:"

SRC_URI += "file://bootsettings.patch \
	   "
