CRIPTION = "FFMPEG"
HOMEPAGE = "http://www.ffmpeg.de"

LICENSE = "LGPL-2.1"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/LGPL-2.1;md5=1a6d268fd218675ffea8be556788b780"

DEPENDS = "yasm-native"

PV = "2.3.3"
SRCREV = "bc259185cb69c6532232be4b2ad57a70ef7ed946"
SRC_URI = "git://source.ffmpeg.org/ffmpeg.git;branch=release/2.3"

