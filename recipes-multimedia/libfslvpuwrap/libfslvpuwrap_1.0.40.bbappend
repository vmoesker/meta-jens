COMPATIBLE_MACHINE = "(mx6curie)"
