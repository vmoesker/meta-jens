FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

DEPENDS_remove = "dbus"
