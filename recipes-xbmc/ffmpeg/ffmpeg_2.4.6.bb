require ffmpeg.inc

PR = "${INC_PR}.1"
SRC_URI = "https://github.com/xbmc/FFmpeg/archive/2.4.6-Helix.tar.gz"
S = "${WORKDIR}/FFmpeg-2.4.6-Helix"
SRC_URI[md5sum] = "92f6208f6908ef1586bf34764ebeb073"
SRC_URI[sha256sum] = "0872316475fc6d546be63cf9f4d6fe8e29c7f873f9a3344aa577b1f7c517b7cf"
